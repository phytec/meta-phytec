FILES_${PN} += "${bindir} ${libdir} ${datadir}"
