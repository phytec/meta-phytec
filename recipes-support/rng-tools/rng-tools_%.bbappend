SYSTEMD_AUTO_ENABLE:${PN}:mx6-generic-bsp = "disable"
SYSTEMD_AUTO_ENABLE:${PN}:mx6ul-generic-bsp = "disable"
