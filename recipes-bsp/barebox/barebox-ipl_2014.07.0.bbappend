COMPATIBLE_MACHINE = "beagleboneblack-1"
