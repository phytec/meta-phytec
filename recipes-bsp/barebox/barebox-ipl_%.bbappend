FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-config:"
COMPATIBLE_MACHINE = "am335x"
