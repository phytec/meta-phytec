CVE_PRODUCT = "denx:u-boot"
CVE_VERSION = "${@d.getVar("PV").split('-')[0]}"
