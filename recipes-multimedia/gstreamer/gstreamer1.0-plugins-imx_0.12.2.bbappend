FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-pxp-blitter-reenable-GRAY8-as-input-format.patch"
