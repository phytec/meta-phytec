SRC_URI:append:am57xx = " \
    file://0001-ARM-dts-Fix-suspend-issue-for-vip.patch \
    file://v2-0001-TI-HACK-rpmsg-introduce-rpmsg_ns_msg_ext-structur.patch \
    file://v2-0002-TI-HACK-remoteproc-add-api-for-retrieving-a-rproc.patch \
    file://v2-0003-TI-HACK-net-rpmsg-add-support-for-new-rpmsg-socke.patch \
    file://v2-0004-TI-HACK-net-rpmsg-add-support-to-handle-a-remote-.patch \
    file://v2-0005-TI-HACK-net-rpmsg-return-ESHUTDOWN-upon-Tx-on-err.patch \
    file://v2-0006-TI-HACK-net-rpmsg-return-ENOLINK-upon-Rx-on-error.patch \
    file://v2-0007-TI-HACK-net-rpmsg-unblock-reader-threads-operatin.patch \
    file://v2-0008-TI-HACK-remoteproc-Fix-multiple-back-to-back-erro.patch \
    file://0001-arm-configs-phytec_ti_defconfig-Enable-CONFIG_RPMSG_.patch \
"
