include linux-common-hardening.inc

RDEPENDS_${KERNEL_PACKAGE_NAME}-base += "phytec-dt-overlays"
