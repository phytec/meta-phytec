FILESEXTRAPATHS:prepend := '${THISDIR}/${BPN}/:'
