COMPATIBLE_MACHINE:phyboard-segin-imx6ul-6 = "phyboard-segin-imx6ul-6"
COMPATIBLE_MACHINE:ti-soc = "ti-soc"
