FILESEXTRAPATHS:prepend := "${THISDIR}/optee-test-4.4.0:"
require recipes-security/optee/optee-test.inc

SRCREV = "695231ef8987866663a9ed5afd8f77d1bae3dc08"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=a8fa504109e4cd7ea575bc49ea4be560"

