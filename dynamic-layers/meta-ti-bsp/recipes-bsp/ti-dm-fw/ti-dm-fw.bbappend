# Freeze the ti-dm-fw version to match with the current
# Linux/U-boot version.
require dynamic-layers/meta-ti-bsp/recipes-bsp/ti-linux-fw/ti-linux-fw-freeze.inc

DM_FIRMWARE:am62axx = "ipc_echo_testb_mcu1_0_release_strip.xer5f"
