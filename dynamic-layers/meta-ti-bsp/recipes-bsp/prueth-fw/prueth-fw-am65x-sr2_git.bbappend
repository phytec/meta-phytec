COMPATIBLE_MACHINE:append = "|am64xx"
