PACKAGECONFIG:append:am57xx = " gallium-llvm"
