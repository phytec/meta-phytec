require mxxprojects-stm32mp2-phytec-common.inc
