GIT_URL = "git://github.com/phytec/dt-stm32mp.git"
BRANCH = "v6.0-phy"
SRCREV = "0db110b5a0188cceb831e52b8b2d986d99bf61a6"

SRC_URI = "${GIT_URL};branch=${BRANCH};protocol=https"

EXT_DT_RELEASE = "stm32mp-r3.1-phy1"
