require phytec-common-tools.inc

IMAGE_INSTALL += "\
    nano \
"
