COMPATIBLE_MACHINE_append = "|am64xx"
