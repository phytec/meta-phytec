PLATFORMLIST_append_am57xx = " \
	tda3xx-evm \
"
