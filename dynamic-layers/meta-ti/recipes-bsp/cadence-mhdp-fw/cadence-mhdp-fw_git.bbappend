COMPATIBLE_MACHINE_append = "|phyboard-izar-am68x-1"
