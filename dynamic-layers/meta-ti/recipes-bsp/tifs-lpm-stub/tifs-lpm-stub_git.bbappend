# Freeze the ti-rtos-firmware version to match with the current
# Linux/U-boot version.
require dynamic-layers/meta-ti/recipes-bsp/ti-linux-fw/ti-linux-fw-freeze.inc
