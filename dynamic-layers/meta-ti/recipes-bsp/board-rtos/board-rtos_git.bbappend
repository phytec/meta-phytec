DEPENDS_append_am57xx = "	\
	gpio-lld-rtos		\
	icss-emac-lld-rtos	\
	pruss-lld-rtos		\
"
