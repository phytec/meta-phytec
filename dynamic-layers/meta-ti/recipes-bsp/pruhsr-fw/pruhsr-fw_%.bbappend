COMPATIBLE_MACHINE_append = "|am57xx"
TARGET_am57xx = "am57xx-pru0-pruhsr-fw.elf am57xx-pru1-pruhsr-fw.elf"
