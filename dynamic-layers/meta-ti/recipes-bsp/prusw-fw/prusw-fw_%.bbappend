COMPATIBLE_MACHINE_append = "|am57xx"
TARGET_am57xx = "am57xx-pru0-prusw-fw.elf am57xx-pru1-prusw-fw.elf"
