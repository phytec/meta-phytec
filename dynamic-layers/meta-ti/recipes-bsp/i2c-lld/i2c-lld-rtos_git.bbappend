DEPENDS_append_am57xx = "	\
	pruss-lld-rtos		\
"
