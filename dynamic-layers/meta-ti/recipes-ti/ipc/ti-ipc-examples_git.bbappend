ALT_PLATFORM_am57xx = "AM572X AM571X"
