COMPATIBLE_MACHINE_append = "|phyboard-izar-am68x-1"
TARGET_PRODUCT_phyboard-izar-am68x-1 = "j721s2_linux"
