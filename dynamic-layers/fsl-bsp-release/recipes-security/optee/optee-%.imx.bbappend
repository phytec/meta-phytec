CVE_VERSION = "${@d.getVar("PV").split('.imx')[0]}"
