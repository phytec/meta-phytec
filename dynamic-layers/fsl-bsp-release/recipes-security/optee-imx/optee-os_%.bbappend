FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# Load with up to 4GB DDR size, also unify TZDRAM start address
EXTRA_OEMAKE:append:mx8m = " CFG_DDR_SIZE=0x100000000 CFG_TZDRAM_START=0x56000000 CFG_CORE_LARGE_PHYS_ADDR=y CFG_CORE_ARM64_PA_BITS=36 "
