RDEPENDS_${PN} += "weston-machine-units"
