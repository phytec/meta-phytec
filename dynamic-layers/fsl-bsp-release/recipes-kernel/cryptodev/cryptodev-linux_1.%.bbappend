SRCREV:mx95-nxp-bsp = "08644db02d43478f802755903212f5ee506af73b"
