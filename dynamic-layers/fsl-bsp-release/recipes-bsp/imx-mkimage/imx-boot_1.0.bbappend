# NOTE: NXP i.MX93 Silicone Revision A0 requires A0 container binary version.
# Thus pass "REV=A0" to imx-mkimage to generate appropriate binary for A0
# silicone based machines.
REV_OPTION:phyboard-segin-imx93-1 = "REV=A0"
