COMPATIBLE_MACHINE = "(mx8mp)"
