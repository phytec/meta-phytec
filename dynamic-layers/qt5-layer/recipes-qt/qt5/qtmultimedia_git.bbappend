FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-imx-Fallback-to-copying-data-if-mapping-has-not-succ.patch \
"
