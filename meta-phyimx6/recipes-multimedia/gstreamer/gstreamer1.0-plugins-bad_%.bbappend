# Copyright (C) 2015 PHYTEC Messtechnik GmbH,
# Author: Stefan Christ <s.christ@phytec.de>

CFLAGS_append_mx6 = " -DLINUX -DEGL_API_FB"
