# Set i.MX specific dependencies and device type
DEPENDS_mx6 += "virtual/libgles2"
EGLINFO_DEVICE_mx6 = "imx6"
