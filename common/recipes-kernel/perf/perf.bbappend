do_configure[depends] += "${PN}:do_populate_lic"
