#We dont want to be linux-dummy a compatible PROVIDER
COMPATIBLE_MACHINE = "none"
