DEPENDS_append_class-native = " jpeg-native"
