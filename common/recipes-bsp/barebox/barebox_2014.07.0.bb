require barebox.inc

SRC_URI += "file://defconfig"
SRC_URI[md5sum] = "a61b97a2fedebc808d4b182c2ca18a0c"
