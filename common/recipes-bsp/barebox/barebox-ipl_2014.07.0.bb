require barebox-ipl.inc

SRC_URI[md5sum] = "f3a93950777916d4b1c2cd366aec8d91"
SRC_URI[sha256sum] = "6dca5c78de8565a15aaa404edbf1bc4663415f0dc69e094f3b621636876285f2"
