#Freescale

SRC_URI_remove_phyflex-imx6-1 = " \
        file://0001-Add-support-for-i.MX-codecs-to-phonon.patch \
        file://0002-i.MX-video-renderer-Allow-v4l-device-from-environmen.patch \
"
