IMAGE_INSTALL += "phyedit"
