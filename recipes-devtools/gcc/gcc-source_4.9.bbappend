FILESEXTRAPATHS_prepend := "${THISDIR}/gcc-4.9:"
SRC_URI_append = " file://0060-gcc-var-tracking.c-backport-from-gcc-trunk-r212178.patch"
