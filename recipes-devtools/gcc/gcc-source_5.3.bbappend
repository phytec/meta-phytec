FILESEXTRAPATHS_prepend := "${THISDIR}/gcc-5.3:"
SRC_URI_append = " file://0061-Backported-from-mainline.patch"
