do_image_wic[depends] += "\
    phytec-bootenv:do_deploy \
"
